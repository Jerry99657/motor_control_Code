void Mecanum_Tick10ms(void) {
    int16_t ax = 0, ay = 0, az = 0, gx = 0, gy = 0, gz = 0;
    MPU6500_GetData(&ax, &ay, &az, &gx, &gy, &gz);
    imu_data_calibration(&gx, &gy, &gz, &ax, &ay, &az);
    eulerian_angles_t angles = imu_get_eulerian_angles((float)gx, (float)gy, (float)gz, (float)ax, (float)ay, (float)az);
    
    if (!s_is_speed_mode) {
        s_target_yaw = angles.yaw;
        s_yaw_integral = 0.0f;
        return;
    }
    
    float final_vx = s_user_vx;
    float final_vy = s_user_vy;
    float final_wz = s_user_wz_raw;

    if (s_angle_closed_loop_en) {
        // Integrate the user rotation command into the target yaw directly
        // Provide a small deadband for the joystick so it does not drift
        float eff_wz = s_user_wz_raw;
        if (eff_wz > -3.0f && eff_wz < 3.0f) eff_wz = 0.0f;
        
        if (eff_wz != 0.0f) {
            s_target_yaw += eff_wz * 0.010f; // 10ms period integration
            if (s_target_yaw > 180.0f) s_target_yaw -= 360.0f;
            else if (s_target_yaw < -180.0f) s_target_yaw += 360.0f;
        }

        float error = s_target_yaw - angles.yaw;
        if (error > 180.0f) error -= 360.0f;
        else if (error < -180.0f) error += 360.0f;
        
        if (error > -1.5f && error < 1.5f) {
            s_yaw_integral = 0.0f;
            final_wz = 0.0f; // Deadband to prevent low-speed whine!
        } else {
            s_yaw_integral += error * 0.010f;
            if (s_yaw_integral > 50.0f) s_yaw_integral = 50.0f;
            if (s_yaw_integral < -50.0f) s_yaw_integral = -50.0f;
            
            float kp = 3.0f; 
            float ki = 0.15f;
            float corr_wz = kp * error + ki * s_yaw_integral;
            
            // Add a friction break-away feedforward so we avoid stalling and whining
            if (corr_wz > 0.0f && corr_wz < 12.0f) corr_wz = 12.0f;
            else if (corr_wz < 0.0f && corr_wz > -12.0f) corr_wz = -12.0f;
            
            if (corr_wz > 100.0f) corr_wz = 100.0f;
            if (corr_wz < -100.0f) corr_wz = -100.0f;
            
            final_wz = corr_wz;
        }
    } else {
        if (final_wz > -3.0f && final_wz < 3.0f) final_wz = 0.0f;
    }
    
    float wz_rad_spd = final_wz * (3.14159265f / 180.0f);
    float wz_comp_spd = wz_rad_spd * ((160.0f + 205.0f) / 2.0f);

    float ms1 = final_vx + final_vy + wz_comp_spd;
    float ms2 = -final_vx + final_vy + wz_comp_spd;
    float ms3 = -final_vx - final_vy + wz_comp_spd;
    float ms4 = final_vx - final_vy + wz_comp_spd;

    Mecanum_HW_SetSpeed(MECANUM_MOTOR_FL, ms1);
    Mecanum_HW_SetSpeed(MECANUM_MOTOR_FR, ms2);
    Mecanum_HW_SetSpeed(MECANUM_MOTOR_RR, ms3);
    Mecanum_HW_SetSpeed(MECANUM_MOTOR_RL, ms4);
}
